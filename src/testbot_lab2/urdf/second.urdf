Commit message: kolorki

File: src/testbot_lab2/urdf/second.urdf (robot description, URDF)
Before this commit: robot robot, 4 links, 3 joints
Links:
- link base_link: geometry visual cylinder length=0.2 radius=0.02
- link link3: geometry visual box size=0.04 0.04 0.4
